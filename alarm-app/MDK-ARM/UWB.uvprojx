# Keil uVision project UWB.uvprojx, settings and files
target UWB452 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F305RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UWB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,GD32F30X_CL,BOOTLOADER_ENABLED,MPU6500,IWDG_ENABLED12
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\DW1000\decadriver;..\DW1000\platform;..\uCOS-II\core;..\uCOS-II\port;..\Bsp;..\main;..\Src;..\User;..\ZLib;..\update;..\MPU6500_MPL5_1\eMPL;..\MPU6500_MPL5_1\Math_fuction;..\MPU6500_MPL5_1\Port_Driver;..\rfid
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group main
    ../main/: main.c gd32f30x_it.c
  group Application/User
    ../Src/: location_data_app.c uwb_beb.c randomapp.c
    ../User/: uwb_anchor.c uwb_common.c uwb_debug.c
    ../Bsp/: can_app.c dm633.c led_app.c beep_app.c logic.c angle_sensor.c iwdg.c wireless.c
  group DWM1000_Driver
    ../DW1000/decadriver/: deca_device.c deca_range_tables.c deca_params_init.c
  group DWM1000_PlatForm
    ../DW1000/platform/: dw1000_bus.c port.c deca_mutex.c deca_sleep.c deca_spi.c
  group ZLib
    ../ZLib/: olist.c
  group MPU6500
    ../MPU6500_MPL5_1/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MPU6500_MPL5_1/Math_fuction/: math_fun.c
    ../MPU6500_MPL5_1/Port_Driver/: mpu6500_driver.c delay.c
  group Bsp
    ../Bsp/: can_bus.c can_buf.c l4can.c spi_bus.c l4spi.c l4x_flash.c bsp_iic.c
  group Update
    ../update/: CanIap.c iapupdate.c
  group UCOS-II_CORE
    ../uCOS-II/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS-II_PORT
    ../uCOS-II/port/: os_cpu_c.c os_dbg.c os_cpu_a.s
  group Drivers/CMSIS
    ../Src/: system_gd32f30x.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_gd32f30x_cl.s
  group rfid
    ../rfid/: rfid_cc1101.c rfid_driver.c
  group doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
